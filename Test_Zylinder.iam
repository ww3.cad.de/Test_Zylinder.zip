# Autodesk Inventor assembly: Test_Zylinder
## iProperties
Created: 2006-08
Part Number: Test_Zylinder
Document SubType Name: Assembly
Designer: Frehe
Author: Frehe
